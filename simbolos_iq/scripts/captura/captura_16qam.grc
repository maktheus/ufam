options:
  parameters:
    author: Matheus Serrao Uchoa
    generate_options: no_gui
    id: captura_16qam
    output_language: python
    title: Captura 16qam
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '16'
    min: '0'
    num_samps: '100000'
    repeat: 'True'
    type: byte
  states: {}
- name: digital_chunks_to_symbols_xx_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: '[(-3-3j)/10**0.5, (-3-1j)/10**0.5, (-3+3j)/10**0.5, (-3+1j)/10**0.5, (-1-3j)/10**0.5, (-1-1j)/10**0.5, (-1+3j)/10**0.5, (-1+1j)/10**0.5, (3-3j)/10**0.5, (3-1j)/10**0.5, (3+3j)/10**0.5, (3+1j)/10**0.5, (1-3j)/10**0.5, (1-1j)/10**0.5, (1+3j)/10**0.5, (1+1j)/10**0.5]'
  states: {}
- name: blocks_head_0
  id: blocks_head
  parameters:
    num_items: '5000'
    type: complex
  states: {}
- name: blocks_vector_sink_x_0
  id: blocks_vector_sink_x
  parameters:
    type: complex
  states: {}

connections:
- [analog_random_source_x_0, '0', digital_chunks_to_symbols_xx_0, '0']
- [blocks_head_0, '0', blocks_vector_sink_x_0, '0']
- [digital_chunks_to_symbols_xx_0, '0', blocks_head_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
