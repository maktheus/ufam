options:
  parameters:
    author: Matheus Serrao Uchoa
    generate_options: qt_gui
    id: aula2_16qam_MATHEUS
    output_language: python
    title: Aula 2 - 16-QAM - Matheus
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '16'
    min: '0'
    num_samps: '100000'
    repeat: 'True'
    type: byte
  states: {}
- name: digital_chunks_to_symbols_xx_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: '[(-3-3j)/10**0.5, (-3-1j)/10**0.5, (-3+3j)/10**0.5, (-3+1j)/10**0.5, (-1-3j)/10**0.5, (-1-1j)/10**0.5, (-1+3j)/10**0.5, (-1+1j)/10**0.5, (3-3j)/10**0.5, (3-1j)/10**0.5, (3+3j)/10**0.5, (3+1j)/10**0.5, (1-3j)/10**0.5, (1-1j)/10**0.5, (1+3j)/10**0.5, (1+1j)/10**0.5]'
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    color1: blue
    grid: 'True'
    gui_hint: 0,0,1,1
    name: Constelacao 16-QAM
    size: '1024'
    tr_tag: ''
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    gui_hint: 1,0,1,1
    label1: I (fase)
    label2: Q (quadratura)
    name: Dominio do tempo 16-QAM
    size: '64'
    srate: samp_rate
    tr_tag: ''
    type: complex
    yunit: ''
    ymax: '1.5'
    ymin: '-1.5'
  states: {}

connections:
- [analog_random_source_x_0, '0', digital_chunks_to_symbols_xx_0, '0']
- [blocks_throttle_0, '0', qtgui_const_sink_x_0, '0']
- [blocks_throttle_0, '0', qtgui_time_sink_x_0, '0']
- [digital_chunks_to_symbols_xx_0, '0', blocks_throttle_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
